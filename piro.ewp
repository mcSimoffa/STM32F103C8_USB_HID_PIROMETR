# IAR project piro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB
  ICCARM.CCIncludePath2: ; Inc\; STM32F103C8\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ; $WS_DIR$\Inc\; STM32F103C8\
  OBJCOPY.OOCOutputFile: piro.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F103xB
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ; Inc\; STM32F103C8\
  group Src
    Src/: cll_stm32F10x_gpio.c main.c systick.c USBHID.c
  group STM32F103C8
    STM32F103C8/: startup_stm32f103xb.s system_stm32f10x.c
